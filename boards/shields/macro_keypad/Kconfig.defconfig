## boards/shields/macro_keypad/Kconfig.defconfig
```kconfig
if SHIELD_MACRO_KEYPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Macro Keyboard"

endif
```
